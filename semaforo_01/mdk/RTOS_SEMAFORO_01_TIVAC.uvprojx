# Keil uVision project RTOS_SEMAFORO_01_TIVAC.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.0.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RTOS_SEMAFORO_01_TIVAC
  c flags: Optim=1 uC99=1 wLevel=2
  c include: ..\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ../source/: main.c retarget.c retarget_tm4c.c
software components: CMSIS:CORE 3.40.0, CMSIS:RTOS:Keil RTX 4.75.0, Device:Startup 1.0.0
